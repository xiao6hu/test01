# Keil uVision project GUIDemo.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GUIDemo
  c flags: Optim=2 uC99=1
  c define: HSE_VALUE=25000000 DATA_IN_ExtSRAM JOYSTICK_ROTATE
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x68000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: main.c
    ./: GUIDemo.c
  group Documentation
    ./: Abstract.txt
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: as above
  output: GUIDemo
  c flags: Optim=4 uC99=1
  c define: HSE_VALUE=25000000 DATA_IN_ExtSRAM JOYSTICK_ROTATE
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x68000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS2:Keil RTX5 5.3.0, Board Support:Joystick 2.0.0, Board Support:Touchscreen 2.0.0, Board Support:emWin LCD 2.0.0, CMSIS Driver:I2C 2.7, Device:STM32Cube Framework:Classic 1.2.1, Device:STM32Cube HAL:Common 1.2.1, Device:STM32Cube HAL:Cortex 1.2.1, Device:STM32Cube HAL:DMA 1.2.1, Device:STM32Cube HAL:GPIO 1.2.1, Device:STM32Cube HAL:I2C 1.2.1, Device:STM32Cube HAL:RCC 1.2.1, Device:STM32Cube HAL:SRAM 1.2.1, Device:Startup 2.2.1, Graphics:CORE 5.42.9, Graphics:Demo:Automotive 5.42.9, Graphics:Demo:BarGraph 5.42.9, Graphics:Demo:Bitmap 5.42.9, Graphics:Demo:ColorBar 5.42.9, Graphics:Demo:Cursor 5.42.9, Graphics:Demo:Fading 5.42.9, Graphics:Demo:Framework 5.42.9, Graphics:Demo:Graph 5.42.9, Graphics:Demo:ListView 5.42.9, Graphics:Demo:RadialMenu 5.42.9, Graphics:Demo:Skinning 5.42.9, Graphics:Demo:Speed 5.42.9, Graphics:Demo:Speedometer 5.42.9, Graphics:Demo:TransparentDialog 5.42.9, Graphics:Demo:Treeview 5.42.9, Graphics:Demo:WashingMachine 5.42.9, Graphics:Display:MCBQVGA_LG 5.42.9, Graphics:Input Device:Joystick 5.42.9, Graphics:Input Device:Touchscreen 5.42.9
