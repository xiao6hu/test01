# Keil uVision project MassStorage.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MassStorage
  c flags: Optim=2 uC99=1
  c define: HSE_VALUE=25000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20004000 size 0x1c000
  memory RVCT10: RAM 0x20000000 size 0x4000
  group Source
    ./: main.c MassStorage.c MemoryDiskImage.c USBD_User_MSC_0.c USBD_User_MSC_1.c
  group Documentation
    ./: Abstract.txt
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: as above
  output: MassStorage
  c flags: Optim=4 uC99=1
  c define: HSE_VALUE=25000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS2:Keil RTX5 5.3.0, Compiler:Event Recorder 1.2.1, Compiler:I/O:File 1.2.1, Compiler:I/O:STDERR 1.2.1, Compiler:I/O:STDIN 1.2.1, Compiler:I/O:STDOUT 1.2.1, Compiler:I/O:TTY 1.2.1, Board Support:Graphic LCD 2.0.0, File System:CORE 6.10.0, File System:Drive:Memory Card 6.10.0, USB:CORE 6.12.0, USB:CORE 6.12.0, USB:Device 6.12.0, USB:Device:MSC 6.12.0, CMSIS Driver:MCI 2.5, CMSIS Driver:USB Device:Full-speed 2.18, CMSIS Driver:USB Device:High-speed 2.18, Device:STM32Cube Framework:Classic 1.2.1, Device:STM32Cube HAL:Common 1.2.1, Device:STM32Cube HAL:Cortex 1.2.1, Device:STM32Cube HAL:DMA 1.2.1, Device:STM32Cube HAL:GPIO 1.2.1, Device:STM32Cube HAL:PWR 1.2.1, Device:STM32Cube HAL:RCC 1.2.1, Device:STM32Cube HAL:SRAM 1.2.1, Device:Startup 2.2.1
