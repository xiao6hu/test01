# Keil uVision project usbhost.uvprojx, settings and files
target usbhost Configuration (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F205VGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usbhost Configuration +hex
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F205xx ,NDEBUG
  c misc: --C99
  c include: ../Inc;../Middlewares/Third_Party/FatFs/src/drivers;../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../Middlewares/Third_Party/FatFs/src;..\Src\SYSTEM\sys;..\Src\SPI;..\Src\SD;..\Src\SYSTEM\usart;..\Src\SYSTEM\delay;..\Src\lights;..\Src\midi;..\Src\study;..\Src\timr;..\Src\usart;..\Src\CPU\STM32;..\Src\KEY;..\Src\UI;..\Src\UI\KS0108;..\Src\StmFlash;..\Src\includes;..\Src\uCOS-II\Ports;..\Src\uCOS-II\Source;..\Src\APP;..\Src\BSP;..\Drivers\FWlib\inc;..\Src\24CXX;..\Src\IIC;..\Src\CANOpen\CanFestival-3\include;..\Src\CANOpen\CanFestival-3\include\STM32;..\Src\CANOpen\CANOpenMaster;..\Src\CANOpen\Trace;..\Src\CANOpen\Device;..\2.9.0\Drivers\STM32F2xx_HAL_Driver\Inc;..\2.9.0\Drivers\STM32F2xx_HAL_Driver\Inc\Legacy;..\2.9.0\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\Src\RTC;..\Src\XFS5152CE;..\Src\game;..\Src\LedControl;..\Src\CRC16;..\Src\MCO;..\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group FWlib
    ../Drivers/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Src/: stm32f1xx_hal_msp.c
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal.c stm32f1xx_ll_usb.c stm32f1xx_hal_rcc.c stm32f1xx_hal_hcd.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group 2.9.0\Drivers\STM32F2xx_HAL_Driver
    ../2.9.0/Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_can.c stm32f2xx_hal_cortex.c stm32f2xx_hal_crc.c stm32f2xx_hal_cryp.c stm32f2xx_hal_dac.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_dcmi.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hash.c stm32f2xx_hal_hcd.c stm32f2xx_hal_i2c.c stm32f2xx_hal_i2s.c stm32f2xx_hal_irda.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_mmc.c stm32f2xx_hal_nand.c stm32f2xx_hal_nor.c stm32f2xx_hal_pccard.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rng.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_sd.c stm32f2xx_hal_smartcard.c stm32f2xx_hal_spi.c stm32f2xx_hal_sram.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c stm32f2xx_hal_usart.c stm32f2xx_hal_wwdg.c stm32f2xx_ll_usb.c
  group Application/User
    ../Src/: stm32f2xx_hal_msp.c main.c stm32f1xx_it.c usb_host.c usbh_conf.c fatfs.c stm32f2xx_it.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../Src/: system_stm32f2xx.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_core.c usbh_pipes.c usbh_ctlreq.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_scsi.c usbh_msc_bot.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f105xc.s
    ../2.9.0/Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f205xx.s
  group CPU
    ../Src/CPU/STM32/: key_cpu.c ks0108_cpu.c iic_cpu.c
  group BSP
    ../Src/BSP/: BSP.c led.c
  group SD
    ../Src/SD/: MMC_SD.C
    ../Src/SPI/: spi_hal.c
  group usart
    ../Src/usart/: uart4.c usart1.c usart2.c
  group study
    ../Src/study/: study.c
  group lights
    ../Src/lights/: lights.c
  group midi
    ../Src/midi/: Keyboard.c midi.c midi_port.c
  group timr
    ../Src/timr/: timr.c
  group delay
    ../Src/SYSTEM/delay/: timr_delay.c
  group UI
    ../Src/UI/: ui.c ks0108.c Menu.C MenuFSM.C MenuFunc.C MenuLanguage.C MenuMain.C MenuMeasure.C MenuPara.C MenuTop.C SetDevice.c Parameters.c
  group key
    ../Src/KEY/: key.c
  group StmFlash
    ../Src/StmFlash/: stmflash.c
  group uCOS-II\Source
    ../Src/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II\Ports
    ../Src/uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group APP
    ../Src/APP/: app.c
  group 24CXX
    ../Src/24CXX/: 24cxx.c
  group IIC
    ../Src/IIC/: iic.c
  group CANOpen\Core
    ../Src/APP/: GlobalVar.c
  group CANOpen\Canfestval
    ../Src/CANOpen/CanFestival-3/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
    F:/Program/STM32_Program/USB_MIDI_UC_OS2_20190510/Src/CANOpen/CanFestival-3/src/: ds401.c
  group CANOpen\CANOpenDriver
    ../Src/CANOpen/CanFestival-3/drivers/STM32/: can_stm32_hal.c timer_stm32_hal.c can_stm32.c timer_stm32.c
  group CANOpen\CANOpenMaster
    ../Src/CANOpen/CANOpenMaster/: CANOpenObjDictConfig.c
  group CANOpen\CANOpenObjectDictionary
    ../Src/CANOpen/CanFestival-3/objdict/: ObjDict.c
  group CANOpen\Device
    ../Src/CANOpen/Device/: device_dio.c
  group CANOpen\Trace
    ../Src/CANOpen/Trace/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group XFS5152CE
    ../Src/XFS5152CE/: XFS5152CE.c
  group game
    ../Src/game/: game1.c game.c game2.c
  group RTC
    ../Src/RTC/: RTC.c
  group LedControl
    ../Src/LedControl/: LedControl.c
  group CRC16
    ../Src/CRC16/: CRC16.c
  group MCO
    ../Src/MCO/: mco.c timer_stm32_hal.c can_stm32_hal.c mcohw_STM32.c user_STM32.c
    ../Src/: can.c
software components: CMSIS:CORE 4.3.0
