# Keil uVision project GUI_VNC.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GUI_VNC
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: GUI_VNC.c GUI_SingleThread.c MyDialogDLG.c
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F207IGHx/STCubeGenerated/Src/: main.c stm32f2xx_it.c
    ./RTE/Device/STM32F207IGHx/STCubeGenerated/Inc/: stm32f2xx_it.h
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: as above
  output: GUI_VNC
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS2:Keil RTX5 5.3.0, Board Support:LED 2.0.0, Board Support:Touchscreen 2.0.0, Board Support:emWin LCD 2.0.0, Network:CORE 7.8.0, Network:Interface:ETH 7.8.0, Network:Socket:BSD 7.8.0, Network:Socket:TCP 7.8.0, Network:Socket:UDP 7.8.0, CMSIS Driver:Ethernet MAC 2.8, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.2.0, CMSIS Driver:I2C 2.8, Device:STM32Cube HAL:Common 1.2.1, Device:STM32Cube HAL:Cortex 1.2.1, Device:STM32Cube HAL:DMA 1.2.1, Device:STM32Cube HAL:ETH 1.2.1, Device:STM32Cube HAL:GPIO 1.2.1, Device:STM32Cube HAL:I2C 1.2.1, Device:STM32Cube HAL:RCC 1.2.1, Device:STM32Cube HAL:SRAM 1.2.1, Device:Startup 2.2.1, Graphics:CORE 5.46.5, Graphics:Display:MCBQVGA_LG 5.46.5, Graphics:Input Device:Touchscreen 5.46.5, Graphics:Tools:GUI Builder 5.46.5, Graphics:VNC Server 5.46.5
