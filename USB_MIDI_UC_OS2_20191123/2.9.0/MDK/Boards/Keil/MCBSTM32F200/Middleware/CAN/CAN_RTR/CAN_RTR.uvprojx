# Keil uVision project CAN_RTR.uvprojx, settings and files
target STM32F207 - Consumer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAN_RTR_Consumer
  c flags: Optim=4 uC99=1
  c define: HSE_VALUE=25000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: main.c CAN_RTR_Consumer.c CAN_RTR_Producer.c
  group Documentation
    ./: Abstract.txt
target STM32F207 - Producer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: as above
  output: CAN_RTR_Producer
  c flags: Optim=4 uC99=1
  c define: HSE_VALUE=25000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS2:Keil RTX5 5.3.0, Compiler:I/O:STDERR 1.2.1, Compiler:I/O:STDIN 1.2.1, Compiler:I/O:STDOUT 1.2.1, Board Support:Graphic LCD 2.0.0, CMSIS Driver:CAN 1.10, Device:STM32Cube Framework:Classic 1.2.1, Device:STM32Cube HAL:Common 1.2.1, Device:STM32Cube HAL:Cortex 1.2.1, Device:STM32Cube HAL:DMA 1.2.1, Device:STM32Cube HAL:GPIO 1.2.1, Device:STM32Cube HAL:PWR 1.2.1, Device:STM32Cube HAL:RCC 1.2.1, Device:STM32Cube HAL:SRAM 1.2.1, Device:Startup 2.2.1
