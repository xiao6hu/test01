# Keil uVision project Example.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Example
  c flags: Optim=2 uC99=1
  c define: HSE_VALUE=25000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: main.c
    ./: example.c
  group Documentation
    ./: Abstract.txt
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: as above
  output: Example
  c flags: Optim=4 uC99=1
  c define: HSE_VALUE=25000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS2:Keil RTX5 5.3.0, Board Support:emWin LCD 2.0.0, Device:STM32Cube Framework:Classic 1.2.1, Device:STM32Cube HAL:Common 1.2.1, Device:STM32Cube HAL:Cortex 1.2.1, Device:STM32Cube HAL:DMA 1.2.1, Device:STM32Cube HAL:GPIO 1.2.1, Device:STM32Cube HAL:RCC 1.2.1, Device:STM32Cube HAL:SRAM 1.2.1, Device:Startup 2.2.1, Graphics:CORE 5.42.9, Graphics:Display:MCBQVGA_LG 5.42.9
